# Keil uVision project WHEELTEC.uvprojx, settings and files
target WHEELTEC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WHEELTEC +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: ..\APP\inc;..\BSP\inc;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\STM32\comm;..\STM32\display;..\STM32\drivers\uart;..\STM32\network;..\STM32\sensors;..\STM32\timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP_SRC
    ../APP/src/: main.c app_context.c app_init.c app_sensor_fusion.c app_alarm.c app_upload.c app_esp8266.c
  group APP_INC
    ../APP/inc/: main.h app_context.h app_init.h app_sensor_fusion.h app_alarm.h app_upload.h app_esp8266.h
  group BSP_SRC
    ../BSP/src/: stm32f4xx_it.c system_stm32f4xx.c
  group BSP_INC
    ../BSP/inc/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_i2c.c stm32f4xx_exti.c
  group STM32_COMM
    ../STM32/comm/: 4GTX.c 4GTX.h
  group STM32_DISPLAY
    ../STM32/display/: LatticeLed.c LatticeLed.h
  group STM32_DRIVERS_UART
    ../STM32/drivers/uart/: usart1.c usart2.c usart2.h usart3.c usart4.c usart5.c usart6.c
  group STM32_SENSORS
    ../STM32/sensors/: gy95t.c gy95t.h HC-SR04.c HC-SR04.h HX711.c HX711.h Radar.c Radar.h
  group STM32_TIMER
    ../STM32/timer/: GPTM0.c GPTM0.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
